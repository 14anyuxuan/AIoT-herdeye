# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MM32F5277E9PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.0.0.8
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BRD_PLUS_F5270 DCACHE_DISABLED
  c include: ..\..\device\drivers;..\..\device\CMSIS\Include;..\..\control_apps;..\..\device;..\app_drv
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\..\device\mdk\linker\mm32f5277e_flash.scf
  group application
    ../: board_init.c board_init.h clock_init.c clock_init.h main.c pin_init.c pin_init.h
  group drivers
    ../../device/drivers/: hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_common.h hal_comp.c hal_comp.h hal_cordic.c hal_cordic.h hal_crc.c hal_crc.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_enet.c hal_enet.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_flexcan.c hal_flexcan.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_mds.c hal_mds.h hal_mds_remap.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_qspi.c hal_qspi.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../../device/: hal_device_registers.h mm32f5277e.h mm32f5277e_features.h system_mm32f5277e.c system_mm32f5277e.h
    ../../device/mdk/: startup_mm32f5277e.S
  group app_drv
    ../app_drv/: cJSON.c cJSON.h relay.c relay.h water_level.c water_level.h door.c door.h lora.c lora.h weight.c weight.h stepperMotor.c stepperMotor.h
